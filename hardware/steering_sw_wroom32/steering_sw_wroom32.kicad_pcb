# Repository suzuking001/steering_sw

File README.md:

# Steering Switch — ESP32 Bluetoothコントローラー

自動車の抵抗式ステアリングスイッチから、Bluetoothキーボードに対応した端末を操作するPlatformIOプロジェクトです。

車種ごとの抵抗値は固定していません。2系統×各16ボタン、電圧／ADC／推定抵抗値による判定、許容幅、回路定数、短押し／ダブルクリック／長押し、操作マクロを日本語Web画面から変更できます。旧コード・Excelは `stearing_sw/` に保存したままです。

## 接続はこの2つだけ

**普段の操作はBluetooth、設定を変えるときだけWi-Fiです。** 車載ルーターがなくても使えます。

1. 操作する端末の「設定 → Bluetooth」で **Steering Switch** を最初に一度登録します。
2. 設定するときは、ESP32の起動後に Wi-Fiで **SteeringSW-xxxxxx** を選び、自動で開く画面を使います。
3. 画面が開かなければ、ブラウザーで **http://192.168.4.1/** を開きます。

パスワードを使うのはWi-Fi接続時だけです。Web画面でのログインはありません。最初のUSB接続時に表示されるWi-Fiパスワードを一度控えてください。

操作の順番は **[かんたん接続ガイド](docs/connection.md)** にまとめています。家庭・車内LANのPCから開くときは、「本体設定 → Wi-Fi接続」に表示される **PC用URL** を使用してください。`192.168.4.1` は設定用Wi-Fiへ直接接続した場合のアドレスです。

## 初回の使い方

1. [配線例](docs/wiring.md)を確認し、最初はUSB給電で動作を確認します。旧資料のACC分圧回路はそのまま使いません。
2. 初回ビルド前に、PlatformIOと同じPython環境で `python -m pip install -r requirements-build.txt` を実行し、Node.jsとnpmを使って `npm ci --prefix web` を実行します。これでWeb資産の圧縮ツールが揃います。その後、PlatformIOでBuild → Uploadを実行します。従来版から今回のOTA対応版へ移行するときも、全消去せずにUSBでUploadしてください。現在のプロジェクトの設定保存領域は同じ位置にあります。手順は [ファームウェア更新](docs/firmware-update.md) を参照してください。CLIの場合、次を実行します。

   ```bash
   pio run
   pio run -t upload
   pio device monitor -b 115200
   ```

   PlatformIO IDEの標準インストールでは、依存ツールの導入に `~/.platformio/penv/bin/python` を使います。この環境で `pio` がPATHにない場合は `/home/hisa/.platformio/penv/bin/pio` を使用できます。ファームウェアは `.pio/build/esp32dev/firmware.bin` です。Web資産も含まれるため、ファイルシステムの別途書き込みは不要です。

3. 115200bpsのシリアル表示から次の値を控えます。
   - `Password`：設定用Wi-Fiへ接続するためのパスワード。
   - `Wi-Fi`：設定用Wi-FiのSSID。`SETUP` コマンドで案内を再表示できます。
4. PC・スマートフォン・タブレットを `SteeringSW-xxxxxx` に接続します。自動で開く設定画面をそのまま使えます。自動表示されない場合は `http://192.168.4.1/` を開きます。Webのパスワード入力は不要です。
5. **キー送信は初期状態でOFFです。**「本体設定 → 入力のライブモニター」で配線と電圧の変化を確認します。
6. 「ボタン割当」で名前を付けてカードを追加します。カードの「学習」を開き、スイッチを押したまま反応した系統の「現在値を設定する」を押します。測定値を確認し、「適用して保存」を押します。
7. 短押し・ダブルクリック・長押しを割り当てたら、カードの「ボタンを保存」を押します。未押下の中心値を設定するときは、スイッチをすべて離して「本体設定 → 入力の詳細設定」で対象系統の「現在値を設定する」を押し、「入力設定を保存」で反映します。
8. [対応端末のショートカット設定例](docs/keyboard.md)でBLEペアリングと専用キー割り当てを設定します。
9. 「本体設定 → 動作設定」の「キー送信を有効にする」をONにし、「動作設定を保存」を押します。停車中に各操作を確認します。

> ハードウェアへの書き込み・実車接続・接続先の端末での操作確認は、この実装作業では行っていません。[検証チェックリスト](docs/verification.md)を使用してください。

## できること

- ライブ表示・学習中は測定値を約125ms間隔で取得。本体設定の2系統の電圧グラフにはESP32側で約25ms間隔で記録した値を反映し、短い押下の変化も表示。本体設定をスクロールしてグラフが画面外にある間は、通常の状態取得で約1秒ごとに履歴を受信。抵抗値が出ないときはADC上限などの理由を表示。
- 入力2系統の名前、電圧／ADC／Ωの判定単位、実際のプルアップ抵抗値、供給電圧、未押下範囲、ヒステリシスを編集。
- 各系統最大16ボタンを追加・削除。ボタン名、中心値、許容幅、各押し方の操作を編集。
- ボタンカードの「テスト」から、選んだ操作を接続先へ1回送信。「機能割当」では機能名をタップして詳細を開き、画面キーボードで選んだキーや編集中の機能全体を試せます。キー送信を有効にしてBLEを接続しておきます。
- 「機能割当」には音量・再生／一時停止・消音・曲送り／曲戻し・Googleマップなどの標準機能が揃っています。機能名をタップすると、名前と送信手順を変更できます。保存すると、その機能を選んでいるすべてのボタンに反映します。
- 「機能割当」の一覧では、機能名をマウスでドラッグすると表示順を変更でき、ドロップした順番が本体に保存されます。
- 標準16機能と、最大11件の自作機能。各機能は最大32ステップ、合計30秒以内。通常キー、修飾キー、メディアキー、ASCII文字列、待ち時間に対応します。
- 「本体設定 → バックアップとメンテナンス → 機能のプリセットを初期値に戻す」で、標準機能の名前と送信手順を戻せます。自作機能、学習値、ボタン割当は保持します。
- 設定用Wi-Fiは電源投入時に起動します。登録済みの2.4GHz Wi-Fiにも並行して接続します。
- 設定用Wi-Fiが見つからない場合は、起動後にBOOTボタンを3秒長押しして起動を再試行できます。設定用Wi-FiではDNSと接続確認用ページで設定画面へ案内。自動表示されなければIPでアクセス。
- IPアドレスまたは `http://steering-sw.local/` でアクセス。mDNSが利用できない端末ではIPを使用。
- Wi-Fiの「保存済み」「接続中」「接続成功／失敗」を分けて表示し、PC用URLを案内。入力したWi-Fiパスワードは保存後も残り、表示切り替えで確認できます。再表示時は「登録済み」と表示します。
- ボタンはカードごと、機能は詳細画面、本体設定は各設定欄で保存します。機能の詳細画面は「保存」か「変更を破棄」で閉じます。学習は確認画面から保存できます。判定単位の変更は、対象系統の未押下とボタンを校正してから「入力設定を保存」で反映します。
- 設定の再起動後復元、名前付き設定のJSONダウンロード／読み込み、初期化、再起動、BLEペアリング削除、操作ログ。
- 「本体設定 → Bluetooth接続」で、暗号化、キーボード・メディアキーの準備状態、ペアリング件数を確認。端末に表示する名前とBluetoothの有効・無効を保存でき、ペアリングを維持した再接続も可能です。
- 本体設定からGitHub Releasesの新しいファームウェアを確認し、Wi-Fiで更新。[初回の準備と使い方](docs/firmware-update.md)
- タッチ端末で入力欄を選んだときやボタン学習中は、Bluetooth接続を保ったままステアリングからのキー送信を一時停止します。
- 将来のACC OFF連動ロック。初期状態は無効。保護済み入力信号と電源保持が必要です。

## 初期割り当て

| ボタン | 短押し | ダブルクリック | 長押し |
|---|---|---|---|
| MUTE | 再生／一時停止 | — | — |
| ＋／－ | 音量変更 | — | 連続で音量変更 |
| MODE | ホーム | アプリ一覧 | Siri |
| ＞ | 次の曲 | — | Googleマップ |
| ＜ | 前の曲 | — | YouTube |
| 通話 | Cmd＋Tab | — | — |
| 電話ON | — | — | パスコード送信（旧版で登録済みの場合） |
| 電話OFF | ロック | — | — |

短押しは離した際に送信します。ダブルクリックを割り当てたボタンでは、単発の短押しは初期値300msの確定待ちがあります。長押しは初期値800msで1回だけ発火し、離した際の短押しを抑制します。音量は安定した押下を検出した直後、続いて450ms後から100ms間隔で送信します。音量短押しに別の長押し／ダブル操作は併用できません。

起動時、設定適用後、学習後、BLE接続・切断後は、安定した未押下状態に戻るまで入力を受け付けません。範囲外への変化は操作中止として扱い、別ボタンへ直接変化しても未押下に戻るまで新しい操作を開始しません。

## Wi-Fiパスワードと復旧

Web画面のログインは廃止しました。設定用Wi-Fi、または同じ家庭・車内LANへ接続した端末から、そのまま設定を編集できます。Wi-Fiへ接続するためのパスワードは維持します。

Wi-Fiパスワードと端末パスコードは設定JSONに含めません。暗号化されていないNVSへ保存し、Webから内容を読み出す機能はありません。以前保存されたWeb管理パスワードは使用しません。

USBシリアルから `SETUP` と改行を送ると、設定用APを起動してSSID・Wi-Fiパスワード・URLを再表示します。`HELP` でコマンドを確認できます。以前の `EASY_SETUP` / `RESET_ADMIN` は接続案内の表示として受け付け、パスワードを変更しません。

「入力・Wi-Fi・パスコードを初期化」は設定用APのパスワードとBLEペアリングを維持します。BLE情報は専用ボタンで削除し、接続先の端末でも登録解除します。

設定用には通常のNVSと分けた128KBの `settings` パーティションを確保します。設定はNVSの2スロットへ交互に書き込み、読み戻して確認した後に有効スロットを切り替えます。起動時は選択スロットが不正ならもう片方を確認します。大きな設定は24KBまでです。失敗時は実行中の設定を維持します。

## 開発と検証

```bash
pio run
scripts/test_native.sh
node --check web/app.js
node scripts/test_web.mjs --embedded
```

ネイティブテストにはC++17コンパイラー、ブラウザーテストにはNode.js 22以降とChromiumが必要です。先に `pio run` で依存ライブラリを取得してください。テストは `.pio/` 以下に生成し、通常のファームウェアビルドには含まれません。ブラウザーテストはHTTPとBLE状態のシミュレーターを使用し、JSON検証には実際のC++実装を使用します。

- `src/config_codec.cpp` / `include/model.h`：設定形式、検証、入力分類、押し方判定。
- `src/runtime.cpp`：5ms周期の入力タスク、学習、ログ、ACC、操作の実行条件。
- `src/hid.cpp` / `src/macro_runner.cpp`：BLE HIDと待機で処理を止めないマクロ実行。
- `src/main.cpp`：認証、Web API、Wi-Fi、復旧コマンド。
- `web/`：端末内で動く画面。ビルド時にJavaScriptとCSSを縮小し、HTMLとともにgzipでファームウェアへ組み込み。
- [APIと設定仕様](docs/api.md)、[配線](docs/wiring.md)、[端末設定例](docs/keyboard.md)、[検証記録](docs/verification.md)。

旧スケッチからはBLE接続時のパスコード自動入力、入力待ちで停止するwhileループ、固定パスコードを引き継いでいません。旧閾値は参考プリセットとして引き継ぎ、実車で校正する方式です。

## KiCad design hardware/steering_sw_wroom32/steering_sw_wroom32.kicad_pcb

Parts:
C1, C2: 3 F / 2.7 V; CP_Radial_D8.0mm_P3.50mm; MPN HV0820-2R7305-R
C3, C4, C8, C9, C10, C14: 100 nF; C_0603_1608Metric
C5: 2.2 µF / 16 V; C_0603_1608Metric
C6, C15: 1 µF / 16 V; C_0603_1608Metric
C7: 2.2 µF / 10 V; C_0603_1608Metric
C11, C12, C13: 10 µF / 10 V; C_0805_2012Metric
D1: TLLR4400; LED_D3.0mm
D2, D3: PESD3V3U1UA; D_SOD-323
D4, D5: BAT54S; SOT-23
D6, D7: PMEG2010ER; D_SOD-123F
D8, D9, D10: TPD1E10B06; D_SOD-523
J1: Steering SW; PinHeader_1x03_P2.54mm_Vertical
J2: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: UART 3.3 V; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 330 Ω; R_0603_1608Metric; Tolerance 1%
R3, R4, R5, R20, R21: 1 kΩ; R_0603_1608Metric; Tolerance 1%
R6: 900 kΩ; R_0603_1608Metric; Tolerance 1%
R7, R17, R18, R19: 10 kΩ; R_0603_1608Metric; Tolerance 1%
R8: 1.24 kΩ; R_0603_1608Metric; Tolerance 1%
R9, R12, R13: 100 kΩ; R_0603_1608Metric; Tolerance 1%
R10: 147 kΩ; R_0603_1608Metric; Tolerance 0.1%
R11: 49.9 kΩ; R_0603_1608Metric; Tolerance 0.1%
R14: 24.9 kΩ; R_0603_1608Metric; Tolerance 0.1%
R15: 10 kΩ; R_0603_1608Metric; Tolerance 0.1%
R16: 390 kΩ; R_0603_1608Metric; Tolerance 0.1%
SW1: RESET; SW_SPST_TL3342; MPN TL3342F160QG
SW2: BOOT; SW_SPST_TL3342; MPN TL3342F160QG
U1: ESP-WROOM-32; ESP32-WROOM-32_Edge; MPN ESP32-WROOM-32-N4
U2: LTC4425EMSE#PBF; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm_ThermalVias
U3: TUSB320LAIRWBR; Texas_X2QFN-12_1.6x1.6mm_P0.4mm
U4: TLV75533PDBVR; SOT-23-5
U5: SN74LVC1G04DCKR; SOT-353_SC-70-5
U6: TLV3011BIDBVR; SOT-23-6
U7: AP7361C-33E-13; SOT-223-3_TabPin2

Connections:
/+3V3: C12.1, C13.1, C14.1, D4.2 (K), D5.2 (K), R1.1, R2.1, R17.1, R18.1, U1.2 (VDD), U7.3 (OUT)
/ADC36: C3.1, D4.3 (COM), R4.2, U1.4 (SENSOR_VP)
/ADC39: C4.1, D5.3 (COM), R5.2, U1.5 (SENSOR_VN)
/BOOT_IO0: R18.2, SW2.1, U1.25 (IO0)
/CAP_MID: C1.2, C2.1, D6.2 (A), D7.1 (K), R12.2, R13.1, U2.10 (VMID)
/CC1: D9.1 (A1), J2.A5 (CC1), U3.1 (CC1)
/CC2: D10.1 (A1), J2.B5 (CC2), U3.2 (CC2)
/CC_1P5A_N: R7.2, U3.7 (OUT1), U5.2
/CHG_EN: R9.1, U2.6 (EN), U5.4
/CHG_FB: R10.2, R11.1, U2.5 (FB)
/ESP_EN: C15.1, R16.2, R17.2, SW1.1, U1.3 (EN), U6.1 (OUT)
/KEY1: D2.1 (K), J1.1, R1.2, R4.1
/KEY2: D3.1 (K), J1.2, R2.2, R5.1
/LED_DRV: R3.1, R19.1, U1.14 (IO12)
/U0RXD: R21.1, U1.34 (RXD0/IO3)
/U0TXD: R20.1, U1.35 (TXD0/IO1)
/USB_3V3: C7.1, C8.1, C9.1, R7.1, U3.12 (VDD), U4.5 (OUT), U5.5 (VCC)
/USB_VBUS: C5.1, C6.1, D8.1 (A1), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R6.1, U2.11 (VIN), U2.12 (VIN), U4.1 (IN), U4.3 (EN)
/UV_REF: U6.4 (IN−), U6.5 (REF)
/VIN: C1.1, C10.1, C11.1, D6.1 (K), R10.1, R12.1, R14.1, U2.1 (VOUT), U2.2 (VOUT), U6.6 (V+), U7.1 (IN)
unnamed: D1.2 (A), R3.2
unnamed: J3.1, R20.2
unnamed: J3.2, R21.2
unnamed: R8.1, U2.3 (PROG)
unnamed: R14.2, R15.1, R16.1, U6.3 (IN+)

Notes on the sheet:
ESP-WROOM-32 ステアリングスイッチ Bluetooth キーボード
ステアリングスイッチ入力と状態表示
USB Type-C 5 V 給電
充電・逆流防止・セルバランス
ESP32の低電圧リセット
J1は受動式抵抗ラダー専用。車両側の端子順・電圧を確認。 外付けTVSとADC側クランプを配置。ADCの未押下電圧と判定値を実機で校正。
赤色LED 約1.4 mA GPIO12は起動ストラップ端子。
1.5 A / 3 A広告時のみ充電を許可。USBデータ線とSBUは開放。
VIN 4.74 V 公称（USB入力電圧に依存）。電流制限 約0.81 A（負荷込み）。各セル 2.45 V 公称 / 2.50 V 最大。
C1/C2は同一型番。容量実測差5%以内を組み合わせる。例示品の使用温度は－40～＋65 °C。
D6/D7はセル逆電圧を抑制。C1/C2を取り付けてから給電し、C5とU2のEPはIC近傍のGND面へ接続。
EN開放 約4.42 V、LOW 約4.20 V（設計値）。VINから3.3 Vを生成。
保持時間の計算例 約5秒（150 mA、1.5 F、ESR合計0.16 Ω、VIN 4.74 → 4.20 V）。 実効保持時間は開発ボードのレギュレータと負荷電流に依存。
冷間始動、無給電VINの逆流、最大負荷時の3.3 Vと保持時間を試作機で確認。
ESP-WROOM-32 モジュール
3.3 V 電源と書き込み
C13・C14はU1の3V3/GND近傍。GNDパッド1・15・38・39を接地。 アンテナ側を基板端から張り出し、周囲の金属を避ける。
J3はピン1 TX、ピン2 RX、ピン3 GND。外部USB-UARTは3.3 V信号を使用。 書き込み開始時はBOOTを押しながらRESETを押して離し、その後BOOTを離す。
ACC 未実装

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
Board: 4 copper layers, 75.0 x 55.0 mm, 65 parts (0 on the bottom side), 27 nets.

Other parts of the board:
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
